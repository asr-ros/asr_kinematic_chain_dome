Commit message: Renamed object_database to asr_object_database

File: launch/dome.urdf (robot description, URDF)
Before this commit: robot pdb_dome, 9 links, 8 joints
Links:
- link ptu_pan_link: geometry visual box size=0.045 0.065 0.044; visual box size=0.046 0.044 0.044
